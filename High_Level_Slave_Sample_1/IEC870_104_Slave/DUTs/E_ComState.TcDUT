TYPE E_ComState :
(
	INIT := 0,
	COMMUNICATION
);
END_TYPE
